# Keil uVision project new.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: new +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\USER;..\ASSIST
  group USER
    ./: main.c
  group ASSIST
    ../ASSIST/: delay.c function.c music.c piano.c record.c sound.c display.c game.c key.c teach.c musicGame.c upup.c
